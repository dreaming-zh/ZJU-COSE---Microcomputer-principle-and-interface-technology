	ORG 0000H
	JMP BEG
	ORG 0100H
BEG:
	MOV R7,#20
	MOV R0,#40H
	
LP1:
	MOV @R0,A
	INC A
	INC R0
	DJNZ R7,LP1

	MOV R7,#20
	MOV R0,#40H+20-1
	MOV R1,#90H
	MOV DPTR,#0040H
	
LP2:
	MOV A,@R0
	MOV @R1,A
	MOVX @DPTR,A
	DEC R0
	INC R1
	INC DPTR
	DJNZ R7,LP2
	
	MOV R7,#20
	MOV R0,#50H
	MOV R1,#90H
	
LP3:
	MOV A,@R1
	MOV @R0,A
	INC R0
	INC R1
	DJNZ R7,LP3
SJMP $
END
