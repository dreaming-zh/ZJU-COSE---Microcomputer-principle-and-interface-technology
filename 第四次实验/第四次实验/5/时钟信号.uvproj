# Keil uVision project 时钟信号.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 时钟信号 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 gdef.h led8.h serial.h LED8.c serial.c 时钟信号.c
